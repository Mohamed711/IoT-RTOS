# Keil uVision project test.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c
    E:/Keil/ARM/INC/TI/TM4C123/: system_TM4C123.h TM4C123GH6PM.h
    E:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
  group files
    ./OS/Scheduler/: contextSwitch.h Initialize.c Initialize.h Process.c Process.h queue.c queue.h realTimeClock.c realTimeClock.h ReSched.c ReSched.h nullProcess.c nullProcess.h scheduler_test.h scheduler_test.c
    ./board/ARM/: contextSwitch.c stackInitialization.c
    ./OS/MMU/: mmu.c mmu.h
    E:/IoT-RTOS/board/ARM/: board_config.h
    E:/IoT-RTOS/OS/Resource Management/: Binary_semp.c Csema.c Resource Management.h
    E:/IoT-RTOS/OS/IPC/: ipc.c ipc.h ipc_test.c ipc_trace.h
    E:/IoT-RTOS/OS/API/: bootloader_tweeka.h Scheduler.h
    ./OS/IPC/: ipc_test.h
  group New Group
    ./OS/: RTOS.h
    ./: RTOS_Headers.h User_Config.h
  group drivers
    ./board/ARM/drivers/gpio/: gpio.c gpio.h
    ./board/ARM/drivers/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pge.h
    ./board/ARM/drivers/interrupt/: interrupt.c interrupt.h
    ./board/ARM/drivers/pin_map/: pin_map.h
    ./board/ARM/drivers/sysctl/: sysctl.c sysctl.h
    ./board/ARM/drivers/timer/: timer.c timer.h HAL_Timer_TivaC.c HAL_Timer_TivaC.h
    ./board/ARM/: tivaHAL.h osTimer.c
    ./board/ARM/drivers/cpu/: cpu.c cpu.h
    ./board/ARM/drivers/debug/: debug.h
    ./board/ARM/drivers/uart/: uart.c HAL_UART.c uart.h HAL_UART.h
